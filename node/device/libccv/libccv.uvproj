# Keil uVision project libccv.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: libccv (library)
  c flags: Optim=1 wLevel=1
  c define: CORE_M4 IPC_MASTER PIXY
  c misc: --gnu
  c include: .
  asm define: NO_CRP
  group Source Group 1
    ./: ccv_algebra.c ccv_basic.c ccv_bbf.c ccv_cache.c ccv_classic.c ccv_convnet.c ccv_daisy.c ccv_dpm.c ccv_ferns.c ccv_icf.c ccv_io.c ccv_memory.c ccv_mser.c ccv_numeric.c ccv_resample.c ccv_sift.c ccv_sparse_coding.c ccv_swt.c ccv_tld.c ccv_transform.c ccv_util.c ccv.h ccv_internal.h ccv_numeric2.c ccv_numeric3.c
    ./3rdparty/sha1/: sha1out.c sha1.h
