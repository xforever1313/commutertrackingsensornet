# Keil uVision project video.uvproj, settings and files
target Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: video +hex
  c flags: Optim=1 wLevel=1
  c define: CORE_M4 IPC_MASTER PIXY
  c misc: --gnu
  c include: .;..\libpixy;..\..\common;..\libccv
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\spifi.sct
  group Source Code
    ./: main_m4.cpp conncomp.cpp exec.cpp progblobs.cpp progvideo.cpp progpt.cpp button.cpp progchase.cpp SiftProg.cpp
    ../libpixy/: libpixy_m4.lib lpc43xx_i2c.c i2c.cpp serial.cpp analogdig.cpp spi.cpp uart.cpp
    ../../common/: blob.cpp blobs.cpp colorlut.cpp qqueue.cpp
    ../libccv/: libccv.lib
target RAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: video +hex
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER PIXY
  c include: ., ..\libpixy, ..\..\common
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\ram.sct
